# Keil uVision project TFT.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TFT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: TFT.s bitmap_partOne.s bitmap_partTwo.s DRAWS.s TFT_INIT.s buttons.s irEmmiter.s rtc.s snakeGame.s integration.s tempAndHum.s IconsBitmap.s IconsTwo.s SCREENS_DRAWS.s StopWatchScreen.s Themes.s AlarmSCREEN.s OmniText.s games.s SnakeHigherLevel.s calcInterface.s Calculator.s calcHelp.s
software components: CMSIS:CORE 6.1.0, Device:GPIO 1.3, Device:Startup 1.0.0
